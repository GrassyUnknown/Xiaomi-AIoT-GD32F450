# Keil uVision project Helloworld.uvprojx, settings and files
target Helloworld (5060960::V5.06 update 7 (build 960)::.\Compiler5)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Helloworld +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: .\Applications\inc;.\CMSIS;.\GD32F450Z_Peripherals\Include;.\CMSIS\GD32F4xx\Include;.\Applications\src
  asm include: .\Applications\inc;.\GD32F450Z_Peripherals\Include;.\CMSIS\inc;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ./Applications/src/: main.c ht16k33.c gd32f330.c bh1750.c
    ./Applications/inc/: ht16k33.h
  group BSP
    ./Applications/src/: gd32f4xx_it.c i2c.c systick.c
  group CMSIS
    ./CMSIS/GD32F4xx/Source/: system_gd32f4xx.c
  group Startup
    ./CMSIS/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group Peripherals
    ./GD32F450Z_Peripherals/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
