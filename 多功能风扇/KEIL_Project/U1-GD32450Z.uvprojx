# Keil uVision project U1-GD32450Z.uvprojx, settings and files
target U1-GD32450Z (5060960::V5.06 update 7 (build 960)::.\Compiler5)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IROM(0x08000000,0x0300000) IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: U1-GD32450Z +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450,USE_USB_HS,USE_USB_FS,USE_ULPI_PHY
  c include: .\Application\inc;.\CMSIS;.\CMSIS\GD\GD32F4xx\Include;.\GD32F4xx_standard_peripheral\Include;.\GD32F450Z_BSP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./Application/src/: gd32f4xx_it.c i2c_test.c main.c systick.c
  group GD32F450Z_BSP
    ./GD32F450Z_BSP/src/: ht16k33.c i2c.c pca9685.c
  group GD32F4xx_Peripherals
    ./GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ./CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group doc
    ./: readme.txt
